# Keil uVision project finalproject.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: finalproject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: scarygame.c scarygame.h audio.c led.c switch.c BitmapReader.c AudioReader.c AudioReader.h digitalCompass.c random.c random.h
    ../inc/: Timer1A.c Timer3A.c startup.s PLL.c TLV5616.c LaunchPad.c Timer0A.c ff.c ST7735withSD.c diskio.c Timer2A.c Timer2A.h Timer4A.c UART.c I2C0.c
software components: CMSIS:CORE 6.1.0
